# IAR project Backup (4) of alarm_ring.ewp, settings and files
configuration SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: alarm_ring.xcl
  XLINK.XExtraOptions: -ynpra
configuration SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
configuration NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ../: alarm.h func.asm lgp.h
    ./: conf_loader.c conf_loader.h config_data.c image.c main.c

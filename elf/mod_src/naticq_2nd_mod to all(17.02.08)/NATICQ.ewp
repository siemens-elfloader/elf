# IAR project NATICQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.IExtraOptions: --separate_cluster_for_initialized_variables
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: obexcopy.exe $EXE_DIR$\NATICQ.elf \Data\Zbin\NatICQ\NATICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" Release_ELKA\Exe\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75; EVILFOX
  postbuild: "obexcopy.exe" Release\Exe\NATICQ.elf \MMCard\NATICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration EVILFOX_ICQ (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; EVILFOX
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ESKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; EVILFOX
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: cl_work.c conf_loader.c config_data.c func.asm history.c language.h main.c mainmenu.c manage_cl.c print.r79 revision.h select_smile.c smiles_loader.c status_change.c strings.c

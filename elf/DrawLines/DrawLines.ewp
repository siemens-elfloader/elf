# IAR project DrawLines.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

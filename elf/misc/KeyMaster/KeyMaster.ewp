# IAR project KeyMaster.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: C:\WINDOWS\System32\irftp.exe $EXE_DIR$\KeyMaster_SGold.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm gui.c main.c

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SecPatch\Sec.ewp</path>
  </project>
  
  <project>
    <path>$WS_DIR$\SecCaller\SecCaller.ewp</path>
  </project>

  <project>
    <path>$WS_DIR$\IMSIReader\IMSIReader.ewp</path>
  </project>

  <batchBuild/>
</workspace>


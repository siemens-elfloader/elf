<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SndDemon.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SndDemon</project>
        <configuration>Release ELKA</configuration>
      </member>
      <member>
        <project>SndDemon</project>
        <configuration>Release NEWSGOLD</configuration>
      </member>
      <member>
        <project>SndDemon</project>
        <configuration>Release SGOLD</configuration>
      </member>
      <member>
        <project>SndDemon</project>
        <configuration>Release X75 no headset</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>NSG</name>
      <member>
        <project>SndDemon</project>
        <configuration>Release ELKA</configuration>
      </member>
      <member>
        <project>SndDemon</project>
        <configuration>Release NEWSGOLD</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>SGOLD</name>
      <member>
        <project>SndDemon</project>
        <configuration>Release SGOLD</configuration>
      </member>
      <member>
        <project>SndDemon</project>
        <configuration>Release X75 no headset</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



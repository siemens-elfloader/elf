# IAR project mpos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ..\!bin\elf2vkp debug\exe\elfloader.elf elfloader.vkp ..\!ff\s75_32.bin
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: mpos_cx75_13.xcl
  group (top)
    ./: additional.c main.asm mpos_cx75_13.xcl

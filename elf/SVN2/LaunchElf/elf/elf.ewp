# IAR project elf.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: elf.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: elf.h func.asm lgp.h main.c visual.c

-carm
-Z(CODE)START,CODE,SWITAB,INITTAB,DATA_ID,DATA_C,CONFIG_DATA_ID=A0065820-A0065B5F

-Z(CODE)PATCH_JUMP=A0065800-A006581F
-Z(CODE)PATCH_ENTRY=A09A3DCC-A09A3DD3

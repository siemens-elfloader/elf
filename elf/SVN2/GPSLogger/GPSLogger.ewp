# IAR project GPSLogger.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\GPSLogger.elf \MMCard\ZBin\Daemons\GPSLogger.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\GPSLogger.elf \MMCard\GPSLogger.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\GPSLogger.elf \MMCard\GPSLogger.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: actions.c actions.h conf_loader.c conf_loader.h config.c csm_work.c csm_work.h func.asm main.c minigps_logger.c minigps_logger.h
    ../inc/: gpslogger_ipc.h

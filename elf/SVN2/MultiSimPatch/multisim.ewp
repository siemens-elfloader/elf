# IAR project multisim.ewp, settings and files
configuration EL71v45 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; TELPF=EL71v45
  ICCARM.CCIncludePath2: 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: EL71v45; NEWSGOLD
  postbuild: .\elf\1n.bat EL71v45 D:\Telephon\proshivki\el71v45\EL71450100.bin
  XLINK.XclFile: .\xls\El71v45\multisim.xcl
configuration E71v45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; TELPF=E71v45
  AARM.ADefines: E71v45; NEWSGOLD
  postbuild: .\elf\1n.bat E71v45 D:\Telephon\proshivki\e71v45\E71_450100.bin
  XLINK.XclFile: .\xls\E71v45\multisim.xcl
configuration S75v47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; TELPF=S75v47
  AARM.ADefines: S75v47; NEWSGOLD
  postbuild: .\elf\1n.bat S75v47 D:\Telephon\proshivki\s75v47\s75_4703_update.bin
  XLINK.XclFile: .\xls\S75v47\multisim.xcl
configuration C75v22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=C75v22
  AARM.ADefines: C75v22
  postbuild: .\elf\1s.bat C75v22 D:\Telephon\proshivki\c75v22\220100_eng.bin
  XLINK.XclFile: .\xls\C75v22\multisim.xcl
configuration M75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=M75v25
  AARM.ADefines: M75v25
  postbuild: .\elf\1s.bat M75v25 D:\Telephon\proshivki\m75v25\M75_250300.bin
  XLINK.XclFile: .\xls\M75v25\multisim.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=CX70v56
  AARM.ADefines: CX70v56
  postbuild: .\elf\1s.bat CX70v56 d:\Telephon\proshivki\cx70v56\560300_rus.bin
  XLINK.XclFile: .\xls\CX70v56\multisim.xcl
configuration S65v58 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=S65v58
  AARM.ADefines: S65v58
  postbuild: .\elf\1s.bat S65v58 D:\Telephon\proshivki\s65v58\580300_rus.bin
  XLINK.XclFile: .\xls\S65v58\multisim.xcl
configuration SK65v50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=SK65v50
  AARM.ADefines: SK65v50
  postbuild: .\elf\1s.bat SK65v50 d:\Telephon\proshivki\sk65v50\500300_rus.bin
  XLINK.XclFile: .\xls\SK65v50\multisim.xcl
configuration SL75v52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; TELPF=SL75v52; DISK0
  AARM.ADefines: SL75v52; NEWSGOLD
  postbuild: .\elf\1n.bat SL75v52 D:\Telephon\proshivki\sl75v52\SL75520100.bin
  XLINK.XclFile: .\xls\SL75v52\multisim.xcl
configuration SL65v53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=SL65v53
  AARM.ADefines: SL65v53
  postbuild: .\elf\1s.bat SL65v53 D:\Telephon\proshivki\sl65v53\530300_rus.bin
  XLINK.XclFile: .\xls\SL65v53\multisim.xcl
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; TELPF=S7Cv47
  AARM.ADefines: S7Cv47; NEWSGOLD
  postbuild: .\elf\1n.bat S7Cv47
  XLINK.XclFile: .\xls\S7Cv47\multisim.xcl
configuration CX75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=CX75v25
  AARM.ADefines: CX75v25
  postbuild: .\elf\1s.bat CX75v25 D:\_install\Phone\Backups\cx75_sw25.bin
  XLINK.XclFile: .\xls\CX75v25\multisim.xcl
configuration CX75v13 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=CX75v13
  AARM.ADefines: CX75v13
  postbuild: .\elf\1s.bat CX75v13 D:\Phone\V_Klay\CX75_SW13.bin
  XLINK.XclFile: xls\CX75v13\multisim.xcl
  group (top)
    ./: multisim_ipc.h OsVar.h
  group emulator
    ./: a3a8.c msim_msg.c sim_access.c
  group Startup
    ./: MyStart.s

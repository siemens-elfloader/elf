# IAR project TalkPhoneND.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c TalkPhoneND.h

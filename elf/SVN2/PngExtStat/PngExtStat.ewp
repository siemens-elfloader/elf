# IAR project PngExtStat.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe $EXE_DIR$\PngExtStat.elf \MMCard\ZBin\utilities\PngExtStat.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: obexcopy.exe $EXE_DIR$\PngExtStat.elf \Data\ZBin\utilities\PngExtStat.elf
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: func.asm main.c

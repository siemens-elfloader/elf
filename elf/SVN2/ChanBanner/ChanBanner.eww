<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ChanBanner.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gui\ChanBannerGUI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\vkp\ChanBanPatch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>NewSGOLD</name>
      <member>
        <project>ChanBanner</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ChanBannerGUI</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ChanBanPatch</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



-carm
-Z(CODE)PATCH_GLOBAL_SCAN=A0B103A2-A0B103AF
-Z(CODE)PATCH_J=A0B103B0-A0B103B7
-Z(CODE)PATCH_WORK_SCAN=A0B109DE-A0B109E1
-Z(CODE)CODE=A0079C00-A0079FFF
-Z(DATA)RXLVLS=A8F1D21E-A8F1D5EA
-carm
-Z(CODE)PATCH_GLOBAL_SCAN=A0B015E6-A0B015F3
-Z(CODE)PATCH_J=A0B015F4-A0B015FB
-Z(CODE)PATCH_WORK_SCAN=A0B01C22-A0B01C25
-Z(CODE)CODE=A0079C00-A0079FFF

-Z(DATA)RXLVLS=A8ED45EA-A8ED49B6
-carm
-Z(CODE)PATCH_GLOBAL_SCAN=A0BBC082-A0BBC08F
-Z(CODE)PATCH_J=A0BBC090-A0BBC097
-Z(CODE)PATCH_WORK_SCAN=A0BBC6BE-A0BBC6C1
-Z(CODE)CODE=A0079C00-A0079FFF
-Z(DATA)RXLVLS=A8E499AA-A8E49D76
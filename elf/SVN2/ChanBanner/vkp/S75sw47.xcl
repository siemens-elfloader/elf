-carm
-Z(CODE)PATCH_GLOBAL_SCAN=A0AEA8DE-A0AEA8EB
-Z(CODE)PATCH_J=A0AEA8EC-A0AEA8F3
-Z(CODE)PATCH_WORK_SCAN=A0AEAF1A-A0AEAF1D
-Z(CODE)CODE=A0079C00-A0079FFF

-Z(DATA)RXLVLS=A8E558CE-A8E55C9A
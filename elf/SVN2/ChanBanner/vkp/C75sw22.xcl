-carm
-Z(CODE)PATCH_GLOBAL_SCAN=A0A7F882-A0A7F88F
-Z(CODE)PATCH_J=A0A7F890-A0A7F897
-Z(CODE)PATCH_WORK_SCAN=A0A7FE78-A0A7FE7B
-Z(CODE)CODE=A0079C00-A0079FFF

-Z(DATA)RXLVLS=A875B37E-A875B74A
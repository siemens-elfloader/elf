# IAR project SieJC.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: "obexcopy.exe" $EXE_DIR$\SieJC.elf \MMCard\ZBin\SieJC\SieJC.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: "obexcopy.exe" $EXE_DIR$\SieJC.elf \Data\ZBin\SieJC\SieJC.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Iconbar_NSG (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ICONBAR
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Iconbar_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; ICONBAR
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: clist_util.c clist_util.h color.c color.h cont_menu.c cont_menu.h groups_util.c groups_util.h item_info.c item_info.h lang.h main.c main.h mainmenu.c moods.c rect_patcher.h roster_icons.c roster_icons.h select_smile.c select_smile.h siejc_ipc.h smiles.c smiles.h stat_info.c stat_info.h status_change.c status_change.h transports_icons.c transports_icons.h
  group Messaging
    ./: message_cmds.c message_cmds.h message_list.c message_list.h
  group Serial_Debug
    ../SerialLib/: serial.asm serial.h
    ./: serial_dbg.c serial_dbg.h
  group Utility
    ./: conf_loader.c conf_loader.h config_color.c config_data.c config_iconbar.c func.asm history.c history.h md5.c md5.h platform.h revision.h string_util.c string_util.h xml_common.h xml_gen.c xml_gen.h xml_parser.c xml_parser.h
    ../zlib/Release/Exe/: zlib_deflate.r79
  group XMPP
    ./: adv_login.c adv_login.h bookmarks.c bookmarks.h jabber.h jabber_util.c jabber_util.h JID_Enter_UI.c JID_Enter_UI.h MUC_Enter_UI.c MUC_Enter_UI.h vCard.c vCard.h

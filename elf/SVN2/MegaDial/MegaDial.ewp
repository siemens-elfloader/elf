# IAR project MegaDial.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\MegaDial.elf \MMCard\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: obexcopy.exe $EXE_DIR$\MegaDial.elf \Data\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: ELKA
  postbuild: obexcopy.exe Release_ELKA\Exe\MegaDial.elf \MMCard\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

# IAR project OwnMelody.ewp, settings and files
configuration CX70sw56 (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild.cmd $PROJ_DIR$ $EXE_DIR$ CX70sw56.bin
  XLINK.XclFile: CX70sw56.xcl
  XLINK.XExtraOptions: -ynpra
configuration C72sw22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  postbuild: postbuild.cmd $PROJ_DIR$ $EXE_DIR$ C72sw22.bin
  XLINK.XclFile: C72sw22.xcl
configuration M75sw25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  postbuild: postbuild.cmd $PROJ_DIR$ $EXE_DIR$ M75sw25.bin
  XLINK.XclFile: M75sw25.xcl
configuration CX75sw25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  postbuild: postbuild.cmd $PROJ_DIR$ $EXE_DIR$ M75sw25.bin
  XLINK.XclFile: CX75sw25.xcl
  group (top)
    ./: entry.asm main.c

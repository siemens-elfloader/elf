# IAR project PatchIdleMemoryLeak.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: 1.xcl
  group (top)
    ./: main.asm

# IAR project cpumon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: E:\boba\projects\!phone\flash\patchs\75\s75\my\cpumon\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy.exe Release\Exe\CpuMon.elf \MMCard\ZBin\Daemons\CpuMon.elf
  XLINK.XclFile: test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: obexcopy.exe Release_ELKA\Exe\CpuMon.elf \MMCard\ZBin\Daemons\CpuMon.elf
  XLINK.XclFile: test.xcl
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: obexcopy.exe $EXE_DIR$\CpuMon.elf \Data\ZBin\Daemons\CpuMon.elf
  XLINK.XclFile: test.xcl
  group (top)
    ./: conf_loader.c config.c func.asm main.c

# IAR project Tagscp1251.ewp, settings and files
configuration Release_El71v45 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ELKA
  postbuild: elf\1.bat el71v45 d:\Telephon\proshivki\el71v45\EL71450100.bin
  XLINK.XclFile: El71v45.xcl
configuration Release_E71v45 (ARM)
  as the first configuration, except:
  postbuild: elf\1.bat e71v45 d:\Telephon\proshivki\e71v45\E71_450100.bin
  XLINK.XclFile: E71v45.xcl
configuration Release_S75v47 (ARM)
  as the first configuration, except:
  postbuild: elf\1.bat s75v47 d:\Telephon\proshivki\s75v47\s75_4703_update.bin
  XLINK.XclFile: s75v47.xcl
  group (top)
    ./: func_ARM.asm func_THUMB.asm main.cpp

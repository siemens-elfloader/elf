-carm
-Z(CODE)START,CODE,SWITAB=A1BC0000-A1BC2000

-Z(CODE)PATCHV1=A05FCAF0-A05FCAF8
-Z(CODE)PATCHV2=A05FC820-A05FC828


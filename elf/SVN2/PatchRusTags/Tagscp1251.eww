<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Tagscp1251.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>buildall</name>
      <member>
        <project>Tagscp1251</project>
        <configuration>Release_E71v45</configuration>
      </member>
      <member>
        <project>Tagscp1251</project>
        <configuration>Release_El71v45</configuration>
      </member>
      <member>
        <project>Tagscp1251</project>
        <configuration>Release_S75v47</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



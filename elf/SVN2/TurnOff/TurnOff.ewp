# IAR project TurnOff.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration Release_D (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DAEMON
configuration Release_NEWSGOLD_D (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; DAEMON
configuration Release_ELKA_D (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; DAEMON
configuration Release_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
configuration Release_D_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DAEMON; X75
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

# IAR project SieGet.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: "obexcopy.exe" $EXE_DIR$\SieGet.elf \MMCard\ZBin\Daemons\SieGet.elf
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: "obexcopy.exe" $EXE_DIR$\SieGet.elf \Data\ZBin\Daemons\SieGet.elf
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  postbuild: as above
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: as above
  group (top)
    ./: csm.cpp csm.h daemon.cpp daemon.h dialog.cpp dialog.h file_works.cpp file_works.h iconpack.cpp iconpack.h langpack.cpp langpack.h log.cpp log.h main.cpp main.h mem.cpp mem.h notify.cpp notify.h string_util.cpp string_util.h url_utils.cpp url_utils.h
  group bcfg
    ./: conf_loader.c conf_loader.h config_data.c config_data.h
  group c++
    ../C++/: _cpp.C _cpp2.cpp
  group gui
    ./: bookmarks.cpp bookmarks.h files_menu.cpp files_menu.h gui.cpp gui.h info.cpp info.h list.cpp list.h log_widget.cpp log_widget.h rect_patcher.cpp rect_patcher.h url_input.cpp url_input.h
  group inc
    ./: func.asm include.h macros.h TODO
  group net
    ./: dns.cpp dns.h http.cpp http.h http_headers.cpp http_headers.h inet.cpp inet.h socket.cpp socket.h url.cpp url.h

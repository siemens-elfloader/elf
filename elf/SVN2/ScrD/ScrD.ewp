# IAR project ScrD.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -yrnpa
  group (top)
    ./: main.cpp

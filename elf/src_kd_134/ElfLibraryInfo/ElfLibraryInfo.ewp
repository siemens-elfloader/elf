# IAR project ElfLibraryInfo.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\ARM\Moi Elf's\ElfLibraryInfo\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c connect.c connect.h elfgroop.c elfgroop.h elfsubmainmenu.c elfsubmainmenu.h func.asm groopmainmenu.c groopmainmenu.h main.c main.h mainmenu.c mainmenu.h submainmenu.c submainmenu.h

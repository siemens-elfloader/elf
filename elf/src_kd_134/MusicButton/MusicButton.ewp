# IAR project MusicButton.ewp, settings and files
configuration EL71sw45 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; EL71SW45
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration S75sw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S75SW47
configuration S75sw52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S75SW52
  group (top)
    ./: func.asm main.c

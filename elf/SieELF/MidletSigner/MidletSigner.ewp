# IAR project MidletSigner.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \MMCard\Zbin\utilities\MidletSigner\$PROJ_FNAME$.elf
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: as above
  group (top)
    ./: base64.c conf_loader.c config_data.c func.asm main.c

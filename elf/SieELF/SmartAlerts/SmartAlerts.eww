<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\alarm_ring\alarm_ring.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SmartAlerts_cfg_editor\SmartAlerts_cfg_editor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SmartAlerts\SmartAlertsC.ewp</path>
  </project>
  <batchBuild/>
</workspace>



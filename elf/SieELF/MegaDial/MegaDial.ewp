# IAR project MegaDial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: F:\SieELF\MegaDial\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  postbuild: obexcopy.exe Release\Exe\MegaDial.elf \MMCard\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe $EXE_DIR$\MegaDial.elf \Data\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: ELKA
  postbuild: obexcopy.exe Release_ELKA\Exe\MegaDial.elf \MMCard\ZBin\Daemons\MegaDial.elf
  XLINK.XclFile: test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

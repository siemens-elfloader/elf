# IAR project TurnOff.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
configuration Release_D (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; DAEMON
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: DAEMON
configuration Release_NEWSGOLD_D (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
configuration Release_ELKA_D (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
configuration Release_X75 (ARM)
  as the first configuration, except:
configuration Release_D_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

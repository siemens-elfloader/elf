<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\alarm_ring\alarm_ring.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\alarm_cfg_editor\alarm_cfg_editor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\new_alarm\new_alarm.ewp</path>
  </project>
</workspace>



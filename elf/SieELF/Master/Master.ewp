# IAR project Master.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_NEWSGOLD_LG3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NEWSGOLD_LG3
  group (top)
    ./: func.asm getConfig.c getConfig.h lang.h main.c main.h optionMenu.c optionMenu.h ptcFileWork.c ptcFileWork.h rect_patcher.h string.c string.h usedstr.c usedstr.h visual.c visual.h

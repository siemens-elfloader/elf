<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SerialTest.ewp</path>
  </project>
  <batchBuild/>
</workspace>



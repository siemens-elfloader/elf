# IAR project Weather.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c config_data.c func.asm img_works.c img_works.h main.c main.h string_works.c string_works.h towns_list.c towns_list.h

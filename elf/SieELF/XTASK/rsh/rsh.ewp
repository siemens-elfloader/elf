# IAR project rsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\tmp\mobile\siemens\elf\###\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: main.asm

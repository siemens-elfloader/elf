# IAR project iBlock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  ICCARM.CCDefines: NDEBUG
  postbuild: irftp $TARGET_PATH$
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c

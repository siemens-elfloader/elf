# IAR project SieTxtView.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NewSGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    src/: bookmark.c buff.c code.c conf_loader.c config.c edit.c file.c history.c input.c main.c menu.c search.c
    ./: func.asm
  group include
    inc/: bmstr.h bookmark.h buff.h code.h conf_loader.h edit.h file.h input.h main.h menu.h search.h swilib.h

# IAR project TMO.ewp, settings and files
configuration Release_NewSGold (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: tmo.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGold (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c save_as.c tmo.xcl
    ../inc/: gpslogger_ipc.h

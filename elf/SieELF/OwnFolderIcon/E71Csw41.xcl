-carm
-Z(CODE)OWM_FOLDER_ICON_HOOK=A07384EC-FFFFFFFF
-Z(CODE)OWM_FOLDER_ICON_BODY,DATA_C=A135CA80-FFFFFFFF


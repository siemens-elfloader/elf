# IAR project GprsD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe Release\Exe\GprsD.elf \MMCard\ZBin\Daemons\GprsD.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

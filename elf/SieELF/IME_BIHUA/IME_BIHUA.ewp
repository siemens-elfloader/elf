# IAR project IME_BIHUA.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: E71Csw41
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Csw41.xcl
configuration ELC1sw41 (ARM)
  as the first configuration, except:
  AARM.ADefines: ELC1sw41
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ ELC1v41
  XLINK.XclFile: ELC1sw41.xcl
configuration C81Csw50 (ARM)
  as the first configuration, except:
  AARM.ADefines: C81Csw50
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ C81Cv50
  XLINK.XclFile: C81Csw50.xcl
configuration S7Csw47 (ARM)
  as the first configuration, except:
  AARM.ADefines: S7Csw47
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: S7Csw47.xcl
  group (top)
    ./: addr.h main.asm

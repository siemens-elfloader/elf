# IAR project dictionary.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release NEW (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ../: FUNC.ASM MYLIB.C
    ../Dictionary/: LzmaDecode.c LzmaDecode.h LzmaTest.c LzmaTypes.h
    ./: MAIN.C

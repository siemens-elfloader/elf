# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; HIGHCOLOR; UNPACK
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ../Arc/Zlib/: ADLER32.C COMPRESS.C CRC32.C CRC32.H DEFLATE.C DEFLATE.H INFFAST.C INFFAST.H INFFIXED.H INFLATE.C INFLATE.H INFTREES.C INFTREES.H TREES.C TREES.H UNCOMPR.C Zconf.h ZLIB.H ZUTIL.C ZUTIL.H
    ./: CPUINTRF.H ERROR.c ERROR.H FILEIO.c FILEIO.H Func.asm HVC.H LOADROM.c LOADROM.H MACROS.H MAIN.c MEMORY.H MEMZ80.c MEMZ80.H PIO.c PIO.H RENDER.c RENDER.H shared.h SMS.c SMS.H STATE.c STATE.H SYSTEM.c SYSTEM.H TYPES.H VDP.c VDP.H Z80.c Z80.H Z80DAA.H
    ../: DIV.R79 Siemens.c SWI.ASM SWILIB.C swilib.h
    ../Arc/: LzmaDecode.c LzmaDecode.h LzmaTest.c LzmaTypes.h UnRar.c UnZip.c

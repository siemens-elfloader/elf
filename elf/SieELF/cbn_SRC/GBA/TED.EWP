# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; HIGHCOLOR; C_CORE; CPP; GBA; FREERAM; FINAL_VERSION
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ../: A1FreeRAM.c DIV.R79 Siemens.c Swi.asm SWILIB.C SWILIB.H
    ./: AGBPRINT.H ARM-NEW.C ARM-NEW.H ARMDIS.H AutoBuild.h Bios.c BIOS.H Cheats.h CheatSearch.h EEprom.c EEprom.h expr.cpp.h Flash.c Flash.h GBA.c GBA.H GBAinline.h Getopt.h Gfx.c Gfx.h Globals.c Globals.h HQ2X.H INTERP.H LQ2X.H Main.c Mode0.c Mode1.c Mode2.c Mode3.c Mode4.c Mode5.c NLS.H PIXEL.C Port.h RTC.C RTC.H Scanline.c Sound.h Sram.c Sram.h System.h Text.h THUMB.C THUMB.H Util.c Util.h

# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; HIGHCOLOR; GRAPH; UNPACK; NOZIP; NORAR
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ../: DIV.R79 Siemens.c Swi.asm SWILIB.C Swilib.h
    ./: FONT.H Main.c RANDOM.H windows.h
    ../Arc/: LzmaDecode.c LzmaDecode.h LzmaTest.c LzmaTypes.h

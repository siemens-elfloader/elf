# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; UNPACK
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ../Arc/Zlib/: ADLER32.C COMPRESS.C CRC32.C CRC32.H DEFLATE.C DEFLATE.H INFFAST.C INFFAST.H INFFIXED.H INFLATE.C INFLATE.H INFTREES.C INFTREES.H TREES.C TREES.H UNCOMPR.C Zconf.h ZLIB.H ZUTIL.C ZUTIL.H
    ./: DIV.R79 Edit.c Tables.h
    ../Arc/: LzmaDecode.c LzmaDecode.h LzmaTest.c LzmaTypes.h UnRar.c UnZip.c
    ../: Siemens.c Swi.asm SWILIB.C SWILIB.H

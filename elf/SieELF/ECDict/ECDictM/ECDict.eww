<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ECDict.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BuildAll - SG,NSG,ELKA</name>
      <member>
        <project>ECDict</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ECDict</project>
        <configuration>Release_ELKA</configuration>
      </member>
      <member>
        <project>ECDict</project>
        <configuration>Release_NEWSGOLD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



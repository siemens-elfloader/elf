# IAR project MusicStart.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  group (top)
    ./: conf_loader.c config_data.c filelist.c func.asm histroy.c main.c menu.c play_list.c

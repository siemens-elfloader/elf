-carm
//-Z(CODE)HOOK=A096B8CC-FFFFFFFF
-Z(CODE)CODE,DATA_C=A135B900-FFFFFFFF
-Z(CODE)HOOK_NEW=A0688A88-FFFFFFFF //F5E73268B7A1201C+4
-carm
-Z(CODE)HOOK=A092243C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A0810300-FFFFFFFF

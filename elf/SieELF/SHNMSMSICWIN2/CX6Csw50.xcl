-carm
-Z(CODE)HOOK=A092802C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A0810300-FFFFFFFF

-carm
-Z(CODE)HOOK=A0929E0C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A0810300-FFFFFFFF
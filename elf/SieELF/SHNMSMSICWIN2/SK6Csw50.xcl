-carm
-Z(CODE)HOOK=A031E4F8-FFFFFFFF
-Z(CODE)CODE,DATA_C=A01FCA00-FFFFFFFF

-carm
//-Z(CODE)HOOK=A096510C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A135B900-FFFFFFFF
//-Z(CODE)HOOK_NEW=A0684498-FFFFFFFF
//-Z(CODE)HOOK_NEW=A06845D8-FFFFFFFF
-Z(CODE)HOOK_NEW=A068455C-FFFFFFFF

-carm
//-Z(CODE)HOOK=A098D710-FFFFFFFF
-Z(CODE)CODE,DATA_C=A155F000-FFFFFFFF
-Z(CODE)HOOK_NEW=A0301138-FFFFFFFF //F5E73268B7A1201C+4
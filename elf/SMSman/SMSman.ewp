# IAR project SMSman.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; LANG_RU
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_RU
configuration Release_NSG_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; LANG_EN
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_EN
  group (top)
    ./: adreslist.c conf_loader.c config_data.c func.asm gui.c history.txt lang.h main.c print.r79 sms_data.h strings.c

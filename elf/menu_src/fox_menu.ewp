# IAR project fox_menu.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: func.asm main.c

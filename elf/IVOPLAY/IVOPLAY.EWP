# IAR project IVOPLAY.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X65
  XLINK.XclFile: E:\Ivo\arm\IVOPLAY\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ReleaseX75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: E:\Ivo\arm\IVOPLAY\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c CONFIG.C FUNC.ASM ivoplay.xcl MAIN.c MAINMENU.C mediafiles.c mediafiles_base.c medialibrary.c playlists.c SPYSOK.C

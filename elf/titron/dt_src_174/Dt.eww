<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\_Dt\DescTop.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\_PLG\FPLG.ewp</path>
  </project>
  <batchBuild/>
</workspace>



# IAR project SMSman.ewp, settings and files
configuration Release_NSG (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; RUS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; RUS
configuration ENG_Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ENG
configuration ENG_Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; ENG
  group (top)
    ./: adreslist.c conf_loader.c config_data.c func.asm main.c

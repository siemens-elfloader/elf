# IAR project mini_gps.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: mini_gps.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XExtraOptions: -ynpra
configuration newsgold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c utils.c

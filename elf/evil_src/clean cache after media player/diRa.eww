<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\diRa.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>PANDEMONIUM</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>PANDEMONIUM</project>
        <configuration>Release_NewSGOLD</configuration>
      </member>
      <member>
        <project>PANDEMONIUM</project>
        <configuration>elka</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



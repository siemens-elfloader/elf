# IAR project BalletMini.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy.exe $EXE_DIR$\BalletMini.elf \MMCard\ZBin\BalletMini\BalletMini.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: "obexcopy.exe" $EXE_DIR$\BalletMini.elf \Data\ZBin\BalletMini\BalletMini.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" $EXE_DIR$\BalletMini.elf \MMCard\ZBin\BalletMini\BalletMini.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration C65 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: C65
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: additems.c conf_loader.c config_data.c destructors.c display_utils.c file_works.c func.asm history.c inet.c lang.c lang.h main.c mainmenu.c parse_oms.c readimg.c string_works.c ToDo.txt url_utils.c url_utils.h urlstack.c view.h
  group jpeglib
    jpeglib/: jinclude.h jpeglib.r79

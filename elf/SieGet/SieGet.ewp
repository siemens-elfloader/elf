# IAR project SieGet.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: csm.cpp csm.h daemon.cpp daemon.h dialog.cpp dialog.h func.asm gui.cpp gui.h log.cpp log.h main.cpp main.h mem.cpp mem.h string_util.cpp string_util.h widget.cpp widget.h
  group c++
    ./: cpp.c cpp2.cpp
  group Net
    ./: dns.cpp dns.h http.cpp http.h http_headers.cpp http_headers.h inet.cpp inet.h socket.cpp socket.h url.cpp url.h

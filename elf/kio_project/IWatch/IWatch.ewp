# IAR project IWatch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe Debug\Exe\IWatch.elf \Data\ZBin\IWatch.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c

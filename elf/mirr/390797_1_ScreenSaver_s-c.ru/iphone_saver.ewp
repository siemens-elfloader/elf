# IAR project iphone_saver.ewp, settings and files
configuration SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
configuration ELKA (ARM)
  as the first configuration, except:
  postbuild: D:\ELF\arm\FastRun\tripper.exe "D:\ELF\arm\1_ScreenSaver\ELKA\Exe\iphone_saver.elf"  "D:\ELF\arm\1_ScreenSaver\ELKA\Exe\iphone_saver0.1.elf"
  group (top)
    ./: main.c readimg.c string_works.c Swi.asm

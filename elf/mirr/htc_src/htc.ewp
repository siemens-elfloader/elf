# IAR project htc.ewp, settings and files
configuration SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: adreslist.c conf_loader.c config_data.c fileman.c main.c readimg.c ScreenShot.c string_works.c Swi.asm ussd_process.c
    jpeglib/: jpeglib.r79

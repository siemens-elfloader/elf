# IAR project ted.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ./: CART.C CART.H CHEAT.C cheat.h CRC32.C CRC32.H DEBUG.C DEBUG.H DRAWING.H driver.h ENDIAN.C endian.h FCEU.C fceu.h FCEUSTR.C FCEUSTR.H FCOEFFS.H FDS.C FDS.H FILE.C file.h FILTER.C FILTER.H FUNC.ASM GENERAL.C GENERAL.H GIT.H INES.C INES.H INPUT.C INPUT.H MD5.C MD5.H MEMORY.C MEMORY.H MOVIE.C MOVIE.H OPS.H PALETTE.C PALETTE.H PPU.C PPU.H PPUTILE.H STATE.C state.h types.h UNIF.C UNIF.H VIDEO.C VIDEO.H VSUNI.C VSUNI.H X6502.C X6502.H x6502struct.h
    ../: MYLIB.C

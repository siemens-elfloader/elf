# IAR project Mirrr_XXX.ewp, settings and files
configuration Release_ELKA (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: F:\ЭLF\Iar1\arm\Rebel Editor\tripper.exe -i "F:\ЭLF\Iar1\arm\Project\Release_ELKA\Exe\Mirrr_XXX.elf" "F:\ЭLF\Iar1\arm\Rebel Editor\XImage.elf"
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration SGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  XLINK.XclFile: F:\ЭLF\Iar1\arm\Project\TEST.XCL
  XLINK.XExtraOptions: -ynpra
configuration ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  XLINK.XExtraOptions: -ynpra
  group (top)
    $EW_DIR$/arm/Rebel Editor/: devka.c readimg.c
    ./: DIV.R79 Main.c register.c Siemens.c Swi.asm
    $EW_DIR$/arm/Rebel Editor/jpeglib/Release/Exe/: jpeglib.r79

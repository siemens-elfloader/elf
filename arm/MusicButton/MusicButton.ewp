# IAR project MusicButton.ewp, settings and files
configuration SGold (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

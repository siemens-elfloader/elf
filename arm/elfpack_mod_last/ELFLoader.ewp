# IAR project ELFLoader.ewp, settings and files
configuration CX70sw56 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX70sw56.txt
  XLINK.XclFile: config\CX70sw56.xcl
configuration CX75sw25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75sw25.txt
  XLINK.XclFile: config\CX75sw25.xcl
configuration SL65sw53 (ARM)
  as the first configuration, except:
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65sw53.txt
  XLINK.XclFile: config\SL65sw53.xcl
configuration S75sw52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\S75sw52.txt
  XLINK.XclFile: config\S75sw52.xcl
configuration EL71sw45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\EL71sw45.txt
  XLINK.XclFile: config\EL71sw45.xcl
configuration E71sw45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\E71sw45.txt
  XLINK.XclFile: config\E71sw45.xcl
configuration C75sw22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\C75sw22.txt
  XLINK.XclFile: config\C75sw22.xcl
  group cfg
    cfg/: conf_loader.c config_data.c
  group main/ASM
    main/: ALTSWI.asm DH.asm ESI.asm EXT2.asm FSWI.asm IMB.asm MFUNC.asm
  group main/C
    main/: additional.c console.cpp dhs.c edl.c elf.c elfloader.c gbsproc.c logger.c paths.c png.c ramlib.c
  group oldfunc
    oldfunc/: rets_C75sw22.asm rets_CX70sw56.asm rets_CX75sw25.asm rets_E71sw45.asm rets_EL71sw45.asm rets_S75sw52.asm rets_SL65sw53.asm

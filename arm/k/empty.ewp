# IAR project empty.ewp, settings and files
configuration CX75v25 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: SL65sw53
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SL65sw53
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v25.txt
  XLINK.XclFile: config\CX75sw25.xcl
configuration E71v45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: E71sw45
  AARM.ADefines: E71sw45
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\E71v45.txt
  XLINK.XclFile: config\E71v45.xcl
  group (top)
    ./: c_empty.c empty.asm

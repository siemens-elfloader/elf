# IAR project IVOPLAY.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X65
  XLINK.XclFile: E:\Ivo\arm\IVOPLAY\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ReleaseX75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; OBS
  XLINK.XclFile: D:\ARM2\IVOPLAY\TEST.XCL
  XLINK.XExtraOptions: -ynpra
configuration ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; OBS
  XLINK.XclFile: D:\ARM2\IVOPLAY\TEST.XCL
  XLINK.XExtraOptions: -ynpra
configuration vovka_el (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; OBS; VOVKA
  XLINK.XclFile: C:\arm\VOPLAY\TEST.XCL
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c CONFIG.C FUNC.ASM headers.c headers.h ipc.h LANGUAGE.H libr.h MAIN.c main.h MAINMENU.C mediafiles.c mediafiles_base.c mediafiles_base.h medialibrary.c myfunc.asm pl.c playlists.c playlists.h rect_patcher.h skins_menu.c snd_buffers.c SPYSOK.C tagmenu.c tagmenu.h

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MailDaemon\MailDaemon.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MailViewer\MailViewer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Batch</name>
      <member>
        <project>MailDaemon</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MailViewer</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Batch NEWSGOLD</name>
      <member>
        <project>MailDaemon</project>
        <configuration>Release_NEWSGOLD</configuration>
      </member>
      <member>
        <project>MailViewer</project>
        <configuration>Release_NEWSGOLD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



# IAR project MyScreenSaver.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration E71Csw41 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; VKP
  AARM.ADefines: VKP
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71C
  XLINK.XclFile: E71Csw41.xcl
configuration E71sw45 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; VKP
  AARM.ADefines: VKP
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71C
  XLINK.XclFile: E71sw45.xcl
  group (top)
    ./: entery.asm func.asm main.c

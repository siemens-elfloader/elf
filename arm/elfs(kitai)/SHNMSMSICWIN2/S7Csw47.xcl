-carm
//-Z(CODE)HOOK=A0996750-FFFFFFFF
-Z(CODE)CODE,DATA_C=A155F000-FFFFFFFF
-Z(CODE)HOOK_NEW=A03027F8-FFFFFFFF //F5E73268B7A1201C+4
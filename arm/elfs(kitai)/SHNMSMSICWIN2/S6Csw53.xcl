-carm
-Z(CODE)HOOK=A092FAB0-FFFFFFFF
-Z(CODE)CODE,DATA_C=A0810300-FFFFFFFF

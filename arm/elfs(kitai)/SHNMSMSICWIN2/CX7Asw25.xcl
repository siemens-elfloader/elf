-carm
-Z(CODE)HOOK=A033618C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A01F9100-FFFFFFFF
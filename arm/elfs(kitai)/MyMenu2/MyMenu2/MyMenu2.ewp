# IAR project MyMenu2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: ..\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration E71Csw41 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; VKP
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71C
  XLINK.XclFile: E71Csw41.xcl
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: ..\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  XLINK.XclFile: ..\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration S7Csw47 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; VKP
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S7C
  XLINK.XclFile: S7Csw47.xcl
  group (top)
    ./: entry.asm main.c
    ../: func.asm

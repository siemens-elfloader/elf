<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FreePaste.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BuildAll - SG,NSG,ELKA</name>
      <member>
        <project>FreePaste</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>FreePaste</project>
        <configuration>Release_NEWSGOLD</configuration>
      </member>
      <member>
        <project>FreePaste</project>
        <configuration>Release_ELKA</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



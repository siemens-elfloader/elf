# IAR project Backup of SP_NSG_MP.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration S7Csw47 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  postbuild: 2vkp.bat $EXE_DIR$
  XLINK.XclFile: S7Csw47.xcl
configuration E71Cv41 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; ELKA
  postbuild: 2vkp.bat $EXE_DIR$
  XLINK.XclFile: E71Cv41.xcl
configuration ELC1v41 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; ELKA
  postbuild: 2vkp.bat $EXE_DIR$
  XLINK.XclFile: ELC1v41.xcl
  group (top)
    ./: div.r79 entry.asm RepSP.c

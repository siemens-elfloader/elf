# IAR project multisim.ewp, settings and files
configuration S7Cv47 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; TELPF=S7Cv47
  ICCARM.CCIncludePath2: 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: S7Cv47; NEWSGOLD
  postbuild: .\elf\1n.bat S7Cv47
  XLINK.XclFile: .\xls\S7Cv47\multisim.xcl
configuration E71Cv41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; TELPF=E71Cv41
  AARM.ADefines: E71Cv41; NEWSGOLD
  postbuild: .\elf\1n.bat E71Cv41 e:\fullflash\lg8\e71cv41.bin
  XLINK.XclFile: .\xls\E71Cv41\multisim.xcl
configuration M81Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; TELPF=M81Cv51
  AARM.ADefines: M81Cv51; NEWSGOLD
  postbuild: .\elf\1n.bat M81Cv51 E:\FULLFLASH\LG8\M81CV51.BIN
  XLINK.XclFile: .\xls\M81Cv51\multisim.xcl
configuration ELC1v41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; TELPF=ELC1v41
  AARM.ADefines: ELC1v41; NEWSGOLD
  postbuild: elf\1n.bat ELC1v41 J:\mobilephone\fullflash\ELC1v41.bin
  XLINK.XclFile: xls\ELC1v41\multisim.xcl
configuration SK6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TELPF=SK6Cv50
  AARM.ADefines: SK6Cv50
  postbuild: .\elf\1n.bat SK6Cv50 E:\FULLFLASH\LG8\SK6Cv50.BIN
  XLINK.XclFile: .\xls\SK6Cv50\multisim.xcl
configuration S68Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; TELPF=S68Cv51; DISK0
  AARM.ADefines: S68Cv51; NEWSGOLD; DISK0
  postbuild: .\elf\1n.bat S68Cv51 E:\FULLFLASH\LG8\S68CV51.BIN
  XLINK.XclFile: xls\S68Cv51\multisim.xcl
configuration S6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; TELPF=S6Cv53
  AARM.ADefines: S6Cv53; SGOLD
  postbuild: elf\1n.bat S6Cv53 J:\mobilephone\fullflash\S6Cv53.bin
  XLINK.XclFile: xls\S6Cv53\multisim.xcl
configuration M6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; TELPF=M6Cv50
  AARM.ADefines: M6Cv50; SGOLD
  postbuild: elf\1n.bat M6Cv50 D:\flash\M6Cv50.bin
  XLINK.XclFile: xls\M6Cv50\multisim.xcl
configuration CX6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; TELPF=CX6Cv50
  AARM.ADefines: CX6Cv50; SGOLD
  postbuild: elf\1n.bat CX6Cv50 D:\flash\CX6Cv50.bin
  XLINK.XclFile: xls\CX6Cv50\multisim.xcl
  group (top)
    ./: multisim_ipc.h OsVar.h
  group emulator
    ./: a3a8.c msim_msg.c sim_access.c
  group Startup
    ./: MyStart.s

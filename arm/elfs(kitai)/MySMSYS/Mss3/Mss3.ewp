# IAR project Mss3.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
configuration Release_S68 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
configuration Release_NSG_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
configuration Release_S68_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: _cpp2.cpp AdrList.cpp AdrList.h AFile.cpp AFile.h CodeShow.cpp CodeShow.h conf_loader.c conf_loader.h config_data.c config_data.h CreateMenu.cpp CreateMenu.h CSMswaper.cpp CSMswaper.h DaemonCSM.cpp DaemonCSM.h define.h DialogCSM.cpp DialogCSM.h EditGUI.cpp EditGUI.h File.cpp File.h func.asm GlobalVariable.cpp GlobalVariable.h IconPack.cpp IconPack.h include.h KeyHook.cpp KeyHook.h LangPack.cpp LangPack.h main.cpp MainMenu.cpp MainMenu.h Mss3App.cpp Mss3App.h MyIpcMessage.cpp MyIpcMessage.h NativeAddressbook.cpp NativeAddressbook.h NumList.cpp NumList.h OthersMenu.cpp OthersMenu.h PopupGUI.cpp PopupGUI.h SendList.cpp SendList.h SiemensPDU.cpp SiemensPDU.h SmsData.cpp SmsData.h SmsListMenu.cpp SmsListMenu.h StrConst.cpp StrConst.h string_works.cpp string_works.h TabGUI.cpp TabGUI.h Template.cpp Template.h TViewGUI.cpp TViewGUI.h Vibra.cpp Vibra.h

# IAR project MssMD.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; LANG_CN; MEGADIAL
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_CN; MEGADIAL
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_EN; NO_CS; MEGADIAL
configuration Release_NEWSGOLD_LG3_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NEWSGOLD_LG3; LANG_EN; NO_CS; MEGADIAL
configuration Release_S68 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; LANG_CN; S68; MEGADIAL
configuration Release_S68_LG3_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NEWSGOLD_LG3; LANG_EN; NO_CS; MEGADIAL; S68
  group (top)
    ./: adrList.c CodeShow.c createMenu.c CSMswaper.c edGui.c Filter.c func.asm guiIdMan.c iconpack.c key_hook.c language.c main.c MegaDial.c NativeAddressbook.c NewDatReader.c numList.c popGui.c sms_dat.c smsList.c string_works.c TabGui.c template.c
  group Config
    ./: conf_loader.c conf_loader.h config_data.c config_data.h
  group Header
    ./: adrList.h CodeShow.h createMenu.h CSMswaper.h edGui.h guiIdMan.h iconpack.h key_hook.h language.h lgp_pic.h main.h MySMSYS_ipc.h NativeAddressbook.h NewDatReader.h numList.h popGui.h rect_patcher.h sms_dat.h smsList.h string_works.h template.h

-carm
-Z(CODE)OWM_FOLDER_ICON_HOOK=A0363788-FFFFFFFF
-Z(CODE)OWM_FOLDER_ICON_BODY,DATA_C=A1200400-FFFFFFFF


# IAR project OwnFolderIcon.ewp, settings and files
configuration S68Csw51 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; S68Csw51
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; S68Csw51
  postbuild: MKvkp.cmd $PROJ_DIR$ $EXE_DIR$ S68Cv51
  XLINK.XclFile: S68Csw51.xcl
configuration E71Csw41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ELKA; E71Csw41
  AARM.ADefines: ELKA; E71Csw41
  postbuild: MKvkp.cmd $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Csw41.xcl
  group (top)
    ./: doChange.c entry.asm

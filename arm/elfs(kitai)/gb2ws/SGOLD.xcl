-carm
-Z(CODE)CODE=A0FA0000-FFFFFFFF
-Z(CODE)SWILIB_242_GB2WS=A0FD4908-FFFFFFFF
-Z(CODE)SWILIB_243_WS2GB=A0FD490C-FFFFFFFF

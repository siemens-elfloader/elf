# IAR project Serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: E:\boba\projects\!phone\flash\patchs\75\s75\my\cpumon\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: test.xcl
  group (top)
    ./: serial.asm serial.h

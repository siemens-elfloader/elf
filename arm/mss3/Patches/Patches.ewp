# IAR project Patches.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71Cv41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA; E71Cv41
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Csw41.xcl
configuration S7Csw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: S7Csw47.xcl
configuration ELC1sw41 (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD; ELKA; ELC1v41
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ ELC1v41
  XLINK.XclFile: ELC1sw41.xcl
configuration E71sw45 (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD; ELKA; E71v45
  postbuild: elf2vkp.bat
  XLINK.XclFile: E71sw45.xcl
configuration C81Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ C81Cv50
  XLINK.XclFile: C81Csw50.xcl
configuration S68Csw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ S68Cv51
  XLINK.XclFile: S68Csw51.xcl
configuration S75sw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ S75v47
  XLINK.XclFile: S75sw47.xcl
configuration S75v52 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: elf2vkp.bat $PROJ_DIR$ $EXE_DIR$ S75v47
  XLINK.XclFile: S75sw52.xcl
  group (top)
    ./: add-on.c entery.asm entry_elka.asm

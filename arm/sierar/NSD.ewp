# IAR project NSD.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: C:\WINDOWS\System32\irftp.exe $TARGET_PATH$
configuration Release_ELKA (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\arm\miosd_src\test.xcl
  group (top)
    settings/zip/: DIV.R79
    ./: func.asm main.c

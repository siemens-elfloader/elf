# IAR project SPlayer.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; OBS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; OBS
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  postbuild: postbuild.bat $TARGET_PATH$ Data\ZBin\SPlayer\SPlayer_SGold.elf
configuration Release_NO_PNG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NO_PNG
configuration Release_ELKA_NO_PNG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; NO_PNG
configuration Release_SGOLD_NO_PNG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75; NO_PNG
  postbuild: postbuild.bat $TARGET_PATH$ Data\ZBin\SPlayer\SPlayer.elf
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c FM.c FM.h func.asm history.txt ID3Genres.h ID3Tags.c item_info.c item_info.h keys.c klib.c lang.h langpack.h main.c main.h mainmenu.c mainmenu.h mylib.h playlist.c playlist.h popup.c Rules.txt setlang.h sets_menu.c sets_menu.h SPlayer_ipc.h

# IAR project E-Racer.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\ARM\E-Racer ALL\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  XLINK.XclFile: test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

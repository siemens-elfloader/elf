<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sie_office_notepad.ewp</path>
  </project>
  <batchBuild/>
</workspace>

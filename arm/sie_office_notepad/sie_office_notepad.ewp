# IAR project sie_office_notepad.ewp, settings and files
configuration Release_ELKA_RU (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: C:\pp\test.xcl
configuration SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\pp\test.xcl
  group (top)
    ./: func.asm main.c

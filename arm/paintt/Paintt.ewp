# IAR project Paintt.ewp, settings and files
configuration SGold (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

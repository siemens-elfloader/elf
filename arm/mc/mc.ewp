# IAR project mc.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild.cmd
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: postbuild.cmd
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  postbuild: postbuild.cmd
  group (top)
    ./: Bookmarks.c ColorMap.c conf_loader.c config.c config_data.c dprop.c encode.c exts.c FileOp.c fn_list.c fprop.c fslib.c func.asm gui.c keys.c krnl.c main.c menus.c mui.c quicksort.c slib.c sort.c TextInput.c zslib.c
  group Inc
    Inc/: ColorMap.h config.h encode.h exts.h gui.h lng.h mc.h mui.h sort.h zslib.h
  group ZLib
    ZLib/: ADLER32.C COMPRESS.C CRC32.C CRC32.H deflate.c DEFLATE.H INFFAST.C INFFAST.H INFFIXED.H INFLATE.C INFLATE.H INFTREES.C INFTREES.H translation.h TREES.C TREES.H UNCOMPR.C Zconf.h zconf.in.h ZLIB.H ZUTIL.C zutil.h
  group ZLib/minizip
    ZLib/minizip/: crypt.h ioapi.c ioapi.h unzip.c unzip.h zip.c zip.h

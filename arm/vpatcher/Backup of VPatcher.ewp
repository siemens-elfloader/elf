# IAR project Backup of VPatcher.ewp, settings and files
configuration Release_ELKA_RU (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: E:\ELF\HelloWorld\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
configuration SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c read.c read.h
  group dimadze
    tbase_work/: tbase.c tbase.h tbsys.asm

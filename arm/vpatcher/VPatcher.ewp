# IAR project VPatcher.ewp, settings and files
configuration NewSGold (E/EL71) (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
configuration SGold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  group (top)
    ./: func.asm main.c
  group config
    config/: conf_loader.c config_data.c
  group tbase
    tbase_work/: tbase.c tbsys.asm
  group utils
    utils/: fileman.c parser.c prepatch.c

# IAR project Backup of hello.ewp, settings and files
configuration Release_ELKA_RU (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\pp\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: C:\pp\test.xcl
configuration SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\arm\AutoNet\test.xcl
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c read.c read.h
  group dimadze
    tbase_work/: interrupts.asm tbase.c tbase.h

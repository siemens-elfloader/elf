# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\installer\TEST.XCL
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ./: ADLER32.C COMPRESS.C CRC32.C CRC32.H DEFLATE.C DEFLATE.H FUNC.ASM INFFAST.C INFFAST.H INFFIXED.H INFLATE.C INFLATE.H INFTREES.C INFTREES.H Main.c TREES.C TREES.H UNCOMPR.C Zconf.h ZLIB.H ZUTIL.C ZUTIL.H

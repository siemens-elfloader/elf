# IAR project IdleLinks.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\Documents and Settings\Admin\Рабочий стол\src\ешко\miosd_src\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NATICQ
  XLINK.XclFile: C:\Downloads\the_evil_sources_130\the_evil_sources\CPUD\test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
configuration EVILFOX_S75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; EVILFOX; NATICQ
  XLINK.XclFile: as above
  group (top)
    ./: clock.c conf_loader.c conf_loader.h config_data.c func.asm gprs_write.c language.h main.c missed_events.c string_works.c

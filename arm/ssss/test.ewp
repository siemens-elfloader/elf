# IAR project test.ewp, settings and files
configuration ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\miosd_src\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration SG (ARM)
  as the first configuration, except:
configuration NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ../ProPlayer/: func.asm
    ./: gui.c main.c nsd.c

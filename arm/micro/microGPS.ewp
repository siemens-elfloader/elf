# IAR project microGPS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: postbuild.cmd $EXE_DIR$ Data\ZBin\WeatherD WeatherD.elf
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: as above
  XLINK.XclFile: C:\arm\278278_ram\test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c string_works.c string_works.h

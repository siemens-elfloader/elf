# IAR project Hello.ewp, settings and files
configuration Nsg (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\ProPlayer\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Elka (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: C:\pp\test.xcl
configuration Release_ELKA_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: C:\arm\pp\test.xcl
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_EN
  XLINK.XclFile: C:\pp\test.xcl
configuration Release_NSG_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; LANG_RU; ELKA
  XLINK.XclFile: C:\pp\test.xcl
configuration Release_NSG_EN (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\pp\test.xcl
  group (top)
    ../ProPlayer/: func.asm
    ./: main.c main.h
  group bmp
    bmp/: bmp.c bmp.h

# IAR project sudoku.ewp, settings and files
configuration NewSGold (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (E/EL71) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_RU
configuration SGold (x65-x75) (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; LANG_RU; DEBUG
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

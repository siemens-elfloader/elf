# IAR project maps.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\amr2wav\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: C:\arm\sudoku\test.xcl
  group (top)
    ./: func.asm include.c include.h main.c string_works.c
  group cache
    cache/: cache.c cache.h
  group config
    ./: conf_loader.c config_data.c
  group draw
    draw/: draw.c draw.h image.c image.h
  group internet
    internet/: internet.c internet.h
  group language
    language/: language.c language.h
  group map
    map/: map.c map.h

-carm
-Z(CODE)CODE,DATA_C,CONFIG_DATA_C=A0FC7D00-FFFFFFFF

-Z(CODE)PATCH_ENTER1=A04AC6DC-A04AC6E3
-Z(CODE)PATCH_ENTER2=A04B7CB4-A04B7CBB

-Z(CODE)PATCH_ENTER3=A0A614DC-A0A614DF

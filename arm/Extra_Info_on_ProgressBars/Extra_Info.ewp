# IAR project Extra_Info.ewp, settings and files
configuration CX75_13 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  postbuild: ..\elfloader\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp C:\\1.bin
  XLINK.XclFile: cx75_13.xcl
configuration E71_45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: ..\elfloader\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp C:\\2.bin
  XLINK.XclFile: e71_45.xcl
  group (top)
    ./: additional.c conf_loader.c config_data.c cx75_13.xcl e71_45.xcl main.asm rets_CX75sw13.asm rets_E71_45.asm

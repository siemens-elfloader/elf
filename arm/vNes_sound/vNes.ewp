# IAR project vNes.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: elf.xcl
  XLINK.XExtraOptions: -ynpra
configuration release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  XLINK.XclFile: elf.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    snd/: audiohook.c NES APU.C
    ./: div.r79 FUNC.ASM MAIN.C menu.h Nes.c Siemens.c Swi.asm SWILIB.C

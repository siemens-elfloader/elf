<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SieJC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All_Platforms</name>
      <member>
        <project>SieJC</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>SieJC</project>
        <configuration>Release_ELKA</configuration>
      </member>
      <member>
        <project>SieJC</project>
        <configuration>Release_SGOLD</configuration>
      </member>
      <member>
        <project>SieJC</project>
        <configuration>Release_SGOLD_X75</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



# IAR project 7zlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: C:\arm\elfs\test.xcl
  group (top)
    ./: 7zAlloc.c 7zBuffer.c 7zCrc.c 7zDecode.c 7zExtract.c 7zHeader.c 7zIn.c 7zItem.c 7zMethodID.c LzmaDecode.c main.c
    ../../Documents and Settings/Андрей/Рабочий стол/111/Embedded Workbench 4.0 Evaluation/ARM/Мой/: func.asm

# IAR project PlayersControl.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c

# IAR project Hello.ewp, settings and files
configuration Release_ELKA (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\pp\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: C:\pp\test.xcl
configuration Release_SG (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\pp\test.xcl
  group (top)
    ../ProPlayer/: func.asm
    ./: main.c

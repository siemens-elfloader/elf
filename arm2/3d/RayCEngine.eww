<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RayCEngine.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build ALL</name>
      <member>
        <project>RayCEngine</project>
        <configuration>Release_ELKA</configuration>
      </member>
      <member>
        <project>RayCEngine</project>
        <configuration>Release_NEWSGOLD</configuration>
      </member>
      <member>
        <project>RayCEngine</project>
        <configuration>Release_SGOLD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



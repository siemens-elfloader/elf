# IAR project amr2wav.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\arm\miosd_src\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ../ProPlayer/: func.asm
    ./: main.c
  group codec
    ./: amrfile.c bitparse.c frmbtord.c interf_dec.c sp_dec.c wavefile.c

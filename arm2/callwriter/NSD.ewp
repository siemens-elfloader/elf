# IAR project NSD.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: after.cmd Release_SGOLD\Exe\ CallRecorder_SGOLD.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: after.cmd Release_ELKA\Exe\ CallRecorder_ELKA.elf
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: after.cmd Release_NEWSGOLD\Exe\ CallWriter_NEWSGOLD.elf
  group (top)
    call/: call.h
    ./: conf_loader.c config_data.c func.asm main.c
    obs/: obs.h

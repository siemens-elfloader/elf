# IAR project BR_MapEditor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\Black Raven\test.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: D:\IAR\ARM\Black Raven\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: G:\Iar\Проекты\Ballet\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: C:\arm\Black raven\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c main.h missions.h

# IAR project IDLEHOOK.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" Release_ELKA\Exe\zMNUEdit_ELKA.elf \Data\zMNUEdit_ELKA.elf
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_X65 (ARM)
  as the first configuration, except:
  XLINK.XclFile: D:\Pasha\elf\ARHIVES\RunShortcuts\CfgEdit\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: main.c menu.c

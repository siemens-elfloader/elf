# IAR project empty.ewp, settings and files
configuration E71v45 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: E71v45
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: E71v45
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\E71v45.txt
  XLINK.XclFile: config\E71v45.xcl
configuration EL71v45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: EL71v45
  AARM.ADefines: EL71v45
  XLINK.XclFile: config\EL71v45.xcl
  group (top)
    ./: c_empty.c empty.asm

-carm
-Z(CODE)PATCH_BODY,START,CODE,SWITAB,INITTAB,DATA_ID,DATA_C,CONFIG_DATA_ID=A1310A00-FFFFFFFF
-Z(DATA)DATA_Z=A8F00700-A8F00800

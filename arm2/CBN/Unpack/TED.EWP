# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; DOS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NOIDLETMR; DOS
  XLINK.XclFile: E:\ARM\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ../: FUNC.ASM Swilib.h
    ./: MAIN.C

<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\amr2wav.ewp</path>
  </project>
  <batchBuild/>
</workspace>

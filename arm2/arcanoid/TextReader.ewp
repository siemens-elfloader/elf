# IAR project TextReader.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: D:\programming\мои проекты\ArcanoidStudio\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: "obexcopy.exe" Release_SGOLD\Exe\TextReader.elf \Data\TextReader.elf
  XLINK.XclFile: D:\создание эльфов\мои проекты\worms\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: D:\programming\мои проекты\ArcanoidStudio\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: config.c config.h engine.c engine.h func.asm main.c menu.c menu.h SpriteLoader.c SpriteLoader.h TextInput.c
